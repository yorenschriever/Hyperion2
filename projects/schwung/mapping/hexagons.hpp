const int hexagonData[12][6] = {

    {115,114,113,116,3,4},
    {16,112,111,110,109,2},
    {10,139,138,137,136,140},
    {106,105,104,108,26,107},
    {8,103,102,101,17,25},
    {1,9,40,135,134,133},
    {35,36,147,146,145,148},
    {127,126,125,18,32,128},
    {118,117,33,41,24,119},
    {141,34,48,144,143,142},
    {129,132,19,20,131,130},
    {120,124,42,123,122,121}
};

int hexagons[12][6*60];

void generateHexagons()
{
    for (int i = 0; i < 12; i++)
    {
        for (int j = 0; j < 6; j++)
        {
            int d = hexagonData[i][j];
            if (d < 100)
            {
                d -= 1;
                d *= 60;

                for (int k=0; k<60; k++)
                {
                    hexagons[i][j*60+k] = d+k;
                }


            } else {
                d -= 101;
                d *= 60;

                for (int k=0; k<60; k++)
                {
                    hexagons[i][j*60+k] = d+59-k;
                }
            }
        }
    }
}